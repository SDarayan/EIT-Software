# Keil uVision project eit.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ./: STM32F10x.s
  group Flash Options
    ./: STM32F10xOPT.s
  group Retarget
    ./: Retarget.c
  group Library
    ./: menu.c StimPattern.c Switching.c ADC.c Serial.c LCD.c OS.c
  group Initialization
    ./: STM32_Init.c
  group Source
    ./: main.c debugMain.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: eit
  c flags: Optim=1
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MCBSTM32 + OPT (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: BlinkyOPT
  c flags: Optim=1
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
